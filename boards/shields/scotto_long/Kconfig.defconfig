## boards/shields/scotto_long/Kconfig.defconfig
```kconfig
if SHIELD_SCOTTO_LONG

config ZMK_KEYBOARD_NAME
    default "scotto-long"

endif # SHIELD_SCOTTO_LONG
```
